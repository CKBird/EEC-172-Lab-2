# Keil uVision project hello.uvproj, settings and files
target hello (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: hello
  AfterMake: fromelf --bin --output .\rvmdk\hello.bin .\rvmdk\hello.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-1.1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: hello.sct
  link misc: --entry Reset_Handler
  group Source
    ./: hello.c startup_rvmdk.S Adafruit_GFX.h Adafruit_SSD1351.h Adafruit_GFX.c Adafruit_SSD1351.c
    C:/ti/TivaWare_C_Series-1.1/utils/: uartstdio.c
  group Libraries
    C:/ti/TivaWare_C_Series-1.1/driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
